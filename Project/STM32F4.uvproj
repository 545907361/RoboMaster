# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\Libraries;..\User;..\BSP;..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c app.c app.h global_define.h global_varialbe.c main.c main.h RM_6623PY.c RM_6623PY.h rm3510.c rm3510.h
  group BSP
    ../BSP/: can1.c can1.h usart1.c usart1.h delay.c delay.h led.c led.h pwm.c pwm.h usart3.c usart3.h timer6.c timer6.h usart2.c usart2.h can2.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c startup_stm32f427xx.s
